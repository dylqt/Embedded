# Keil uVision project lifeRf.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lifeRf +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c BLE.c delay.c indy.c stc15_oled.c stc15_adc.c stc15_uart.c stc15_flash.c stc15_pwm.c stc15_time.c stc15_spi.c stc15_int.c beep.c stc15_clk.c power.c keyScan.c oled_data.c
